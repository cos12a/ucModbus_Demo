# IAR project ucModbusCore.ewp, settings and files
configuration ucModbusTest (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; TX_MISRA_ENABLE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\..\ThreadX\inc; ..\..\ThreadX\iarPort\inc; ..\..\threadx\common\inc; ..\ThreadX\iarPort; ..\ThreadX\iarPort\inc; ..\..\SEGGER_RTT; ..\STM32F1Drivers\Drivers\STM32F1xx_HAL_Driver\Inc; ..\STM32F1Drivers\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy; ..\STM32F1Drivers\Drivers\CMSIS\Include; ..\STM32F1Drivers\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\UserFile\Inc; ..\ThreadX\inc; ..\..\ucModbus\Source; ..\..\ucModbus\Ports; ..\..\ucModbus\Cfg; ..\..\ucModbus\OS\ThreadX; ..\..\ThreadX\inc; ..\..\ThreadX\iar_Port\inc; ..\..\Shell\UartLib; ..\..\ThreadX\M3_IAR_Port\inc; ..\..\ThreadX\common\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ucModbusTest.hex
  ILINK.IlinkOutputFile: ucModbusTest.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ucModbus/ModbusCore
    ../../ucModbus/Source/: mb_util.c mbm_core.c mbs_core.c
