# IAR project STM32_uart_lib.ewp, settings and files
configuration STM32uart_DMA (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\UartLib; E:\DiskE\ThreadX_RTOS\uart_DMA_lib\UartLib\FIFO
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32uart_DMA.hex
  ILINK.IlinkOutputFile: STM32uart_DMA.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group UartLib
    ../../../UartLib_Source/: UART2_IRQ_handler.c uart_lib_test.c Usart2_DMA_hal.c Usart2_UART_hal.c User_hal_dma.c User_hal_uart.c User_IRQ_handler.c
