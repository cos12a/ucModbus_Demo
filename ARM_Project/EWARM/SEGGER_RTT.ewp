# IAR project SEGGER_RTT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: TX_MISRA_ENABLE
  ICCARM.CCIncludePath2: ..\..\ThreadX\inc; ..\..\ThreadX\src; ..\..\ThreadX\iarPort\inc; ..\..\ThreadX\iarPort
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ThreadX.out
  group inc
    ../../SEGGER_RTT/: SEGGER_RTT.h SEGGER_RTT_Conf.h
  group src
    ../../../SEGGER_RTT_Source/: SEGGER_RTT.c SEGGER_RTT_printf.c
