# IAR project STM32ucshell.ewp, settings and files
configuration uc_shell_lib (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; TX_MISRA_ENABLE; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\..\ShellucShell\Cfg; ..\..\ShellucShell\Cmd; ..\..\Shell\ucShell\Source; ..\..\Shell\ucShell\Cfg; ..\..\Shell\ucShell\Terminal\Mode\VT100; ..\..\Shell\ucShell\Terminal\OS\ThreadX; ..\..\Shell\ucShell\Terminal\Serial; ..\..\Shell\ucShell\Terminal\Source; ..\..\Shell\UartLib; ..\..\Shell\ucShell\ucLib; ..\..\ThreadX\inc; ..\..\ThreadX\iar_Port\inc; ..\..\Shell\ucShell\Terminal\Cfg; ..\UserCode\Inc; ..\..\Shell\ucShell\Cmd; ..\..\SEGGER_RTT; ..\Drivers\STM32F1xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F1shellTEST.hex
  ILINK.IlinkOutputFile: STM32ucshell_tx_demo.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ucShell_lib_rtt (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; E:\DiskE\ThreadX_RTOS\ucModbus_Demo\Shell\ucShell\Terminal; ..\..\ShellucShell\Cfg; ..\..\ShellucShell\Cmd; ..\..\Shell\ucShell\Source; ..\..\Shell\ucShell\Cfg; ..\..\Shell\ucShell\Terminal\Mode\VT100; ..\..\Shell\ucShell\Terminal\OS\ThreadX; ..\..\Shell\ucShell\Terminal\Serial; ..\..\Shell\ucShell\Terminal\Source; ..\..\Shell\UartLib; ..\..\Shell\ucShell\ucLib; ..\..\ThreadX\inc; ..\..\ThreadX\iar_Port\inc; ..\..\Shell\ucShell\Terminal\Cfg; ..\UserCode\Inc; ..\..\Shell\ucShell\Cmd; ..\..\SEGGER_RTT; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\ThreadX\common\inc; ..\..\ThreadX\M3_IAR_Port\inc
  group ucshell/cfg
    ../../Shell/ucShell/Cfg/: shell_cfg.h
  group ucshell/sh_shell
    ../../../ucShell_Source/ucShell/Cmd/: sh_shell.c sh_shell.h
  group ucshell/shell
    ../../../ucShell_Source/ucShell/Source/: shell.c shell.h
  group ucshell/Terminal
    ../../../ucShell_Source/ucShell/Terminal/Source/: terminal_direct.c
    ../../../ucShell_Source/ucShell/Terminal/Serial/: terminal_serial.c
  group ucshell/Terminal/OS
    ../../../ucShell_Source/ucShell/Terminal/OS/ThreadX/: terminal_os.c
  group ucshell/uclib
    ../../../ucShell_Source/ucShell/ucLib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
