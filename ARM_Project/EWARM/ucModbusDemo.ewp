# IAR project ucModbusDemo.ewp, settings and files
configuration ucModbusTest (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\..\ThreadX\inc; ..\..\ThreadX\iarPort\inc; ..\..\threadx\common\inc; ..\ThreadX\iarPort; ..\ThreadX\iarPort\inc; ..\..\SEGGER_RTT; ..\STM32F1Drivers\Drivers\STM32F1xx_HAL_Driver\Inc; ..\STM32F1Drivers\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy; ..\STM32F1Drivers\Drivers\CMSIS\Include; ..\STM32F1Drivers\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\UserFile\Inc; ..\ThreadX\inc; ..\..\ucModbus\Source; ..\..\ucModbus\Ports; ..\..\ucModbus\Cfg; ..\..\ucModbus\OS\ThreadX; ..\..\ThreadX\inc; ..\..\ThreadX\iar_Port\inc; ..\..\Shell\UartLib; ..\..\Shell\ucShell\Source; ..\UserCode\Inc; ..\..\ThreadX\inc; ..\..\ThreadX\src; ..\..\ThreadX\iarPort\inc; ..\..\ThreadX\iarPort; ..\..\ThreadX\M3_IAR_Port\inc; ..\..\ThreadX\common\inc; ..\..\..\ucModbus_Source\ucModbus\Cfg; ..\..\..\ucModbus_Source\ucModbus\OS\ThreadX; ..\..\..\ucModbus_Source\ucModbus\Ports; ..\..\..\ucModbus_Source\ucModbus\Source; ..\..\..\ucModbus_Source\ucModbus\mb_cmd; ..\..\..\ucShell_Source\ucShell\ucLib; ..\..\..\ucShell_Source\ucShell\Cfg; ..\..\..\ucShell_Source\ucShell\Terminal\Serial; ..\..\..\ucShell_Source\ucShell\Terminal\Cfg; ..\..\..\ucShell_Source\ucShell\Terminal\Source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\ucModbus_Source\ucModbus\Cfg; ..\..\..\ucModbus_Source\ucModbus\OS\ThreadX; ..\..\..\ucModbus_Source\ucModbus\Ports; ..\..\..\ucModbus_Source\ucModbus\Source; ..\..\..\ucModbus_Source\ucModbus\mb_cmd
  OBJCOPY.OOCOutputFile: ucModbusTest.hex
  ILINK.IlinkOutputFile: ucModbusTest.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../UserCode/Src/: modbus_value.c
  group Application/User
    ../Core/Src/: main.c stm32f1xx_it_user.c usart.c
    ../UserCode/Src/: sample_threadx.c stm32f1xx_hal_uart.c
  group Drivers
    ../LibFile/: STM32F1HalLib.a
  group Mdbus/ucModbus/Cfg
    ../../../ucModbus_Source/ucModbus/Cfg/: mb_cfg.h mb_data.c
  group Mdbus/ucModbus/mb_cmd
    ../../../ucModbus_Source/ucModbus/mb_cmd/: mb_cmd.c
  group Mdbus/ucModbus/OS/ThreadX
    ../../../ucModbus_Source/ucModbus/OS/ThreadX/: mb_os.c
  group Mdbus/ucModbus/Ports
    ../../../ucModbus_Source/ucModbus/Ports/: mb_bsp.c
  group Mdbus/ucModbus/Source
    ../../../ucModbus_Source/ucModbus/Source/: mb.c mb_util.c mbm_core.c mbs_core.c
  group SEGGER_RTT
    ../LibFile/: SEGGER_RTT.a
  group threadX
    ../LibFile/: ThreadX.a
  group ucShell
    ../LibFile/: STM32ucshell.a
  group ucShell/src
    ../../../ucShell_Source/ucShell/Source/: shell.c
    ../../../ucShell_Source/ucShell/Terminal/Serial/: terminal_serial.c
  group ucShell/UartPort
    ../LibFile/: STM32_uart_lib.a
  group ucShell/UartPort/src
    ../../../UartLib_Source/: UART2_IRQ_handler.c Usart2_DMA_hal.c Usart2_UART_hal.c User_hal_dma.c User_hal_uart.c User_IRQ_handler.c user_uart2_cfg.h user_uart_lib.h
