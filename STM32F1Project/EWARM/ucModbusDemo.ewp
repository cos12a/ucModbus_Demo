# IAR project ucModbusDemo.ewp, settings and files
configuration ucModbusTest (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; TX_MISRA_ENABLE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\..\ThreadX\inc; ..\..\ThreadX\iarPort\inc; ..\..\threadx\common\inc; ..\ThreadX\iarPort; ..\ThreadX\iarPort\inc; ..\..\SEGGER_RTT; ..\STM32F1Drivers\Drivers\STM32F1xx_HAL_Driver\Inc; ..\STM32F1Drivers\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy; ..\STM32F1Drivers\Drivers\CMSIS\Include; ..\STM32F1Drivers\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\UserFile\Inc; ..\ThreadX\inc; ..\..\ucModbus\Source; ..\..\ucModbus\Ports; ..\..\ucModbus\Cfg; ..\..\ucModbus\OS\ThreadX
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ucModbusTest.hex
  ILINK.IlinkOutputFile: ucModbusTest.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Core/Src/: main.c
    ../UserCode/Src/: sample_threadx.c stm32f1xx_hal_uart.c stm32f1xx_it.c
  group Drivers
    ../LibFile/: STM32F1HalLib.a
  group SEGGER_RTT
    ../LibFile/: SEGGER_RTT.a
  group threadX
    ../LibFile/: ThreadX.a
  group ucModbus/Cfg
    ../../ucModbus/Cfg/: mb_cfg.h
  group ucModbus/MB
    ../../ucModbus/Source/: mb.c mb.h mb_def.h
    ../../ucModbus/Cfg/: mb_data.c
  group ucModbus/ModbusCore
    ../LibFile/: ucModbusCore.a
  group ucModbus/modbusOS
    ../../ucModbus/OS/ThreadX/: mb_os.c mb_os.h
  group ucModbus/ModbusPorts
    ../../ucModbus/Ports/: cpu.h mb_bsp.c mb_bsp.h
