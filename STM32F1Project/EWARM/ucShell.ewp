# IAR project ucShell.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: TX_MISRA_ENABLE
  ICCARM.CCIncludePath2: ..\..\xprintf
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ThreadX.out
  group inc
    ../../xprintf/: xprintf.h
  group src
    ../../xprintf/: xprintf.c
